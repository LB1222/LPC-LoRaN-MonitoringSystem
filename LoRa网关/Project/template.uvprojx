# Keil uVision project template.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User\bsp;..\User\bsp\inc;..\User\system;..\User\bsp\CJSON
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c
  group BSP
    ../User/bsp/src/: bsp_led.c bsp_timer.c esp8266.c MqttKit.c onenet.c usart.c bsp_date.c bsp_i2c.c OLED.c
    ../User/bsp/: bsp.c bsp.h
    ../User/bsp/inc/: esp8266.h MqttKit.h onenet.h
  group SYSTEM
    ../User/system/: stm32f10x_assert.c stm32f10x_it.c sys.h
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_tim.c
  group CJSON
    ../User/bsp/CJSON/: cJSON.c
