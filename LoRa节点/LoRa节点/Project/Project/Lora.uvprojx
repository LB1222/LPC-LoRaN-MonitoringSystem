# Keil uVision project Lora.uvprojx, settings and files
target Flash (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lora +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User\system;..\User\bsp;..\User\bsp\inc;..\User\bsp\src;..\User\DATEANALYSIS;..\User\POWERMG;..\User\SensorEN
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../User/: main.c
  group BSP
    ../User/bsp/src/: bsp_timer.c bsp_led.c bsp_key.c bsp_beep.c usart.c OLED.c bsp_adc.c bsp_Gps.c bsp_Co2.c bsp_i2c.c
    ../User/bsp/: bsp.c bsp.h
    ../User/bsp/inc/: bsp_key.h bsp_led.h bsp_beep.h usart.h OLED.h
  group SYSTEM
    ../User/system/: stm32f10x_assert.c stm32f10x_it.c sys.h
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c core_cm3.h system_stm32f10x.c system_stm32f10x.h
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group PWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_iwdg.c stm32f10x_bkp.c
  group DATEANALYSIS
    ../User/DATEANALYSIS/: bsp_dateanalysis.c
    ../User/bsp/src/: bsp_dateupload.c
  group POWERMG
    ../User/POWERMG/: bsp_powermanage.c
  group SensorEN
    ../User/SensorEN/: bsp_Modifyregister.c
